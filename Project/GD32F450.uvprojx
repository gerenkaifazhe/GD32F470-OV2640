# Keil uVision project GD32F450.uvprojx, settings and files
target GD32F450 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F450 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Firmware\GD32F4xx_standard_peripheral\Include;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\User;..\Hardware\led;..\Hardware\Lcd;..\Hardware\Gui;..\Hardware\DMA;..\Hardware\DCI;..\Hardware\MyI2C;..\Hardware\OV2640;..\Hardware\TIMER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: systick.c main.c gd32f4xx_it.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Hardware
    ../Hardware/led/: bsp_led.c
    ../Hardware/Lcd/: Lcd.c Spi4.c
    ../Hardware/Gui/: Gui.c
    ../Hardware/DMA/: MyDMA.c MyDMA.h
    ../Hardware/DCI/: DCI.c DCI.h
    ../Hardware/MyI2C/: MyIIC.c MyIIC.h
    ../Hardware/OV2640/: OV2640.c OV2640.h OV2640_Register.h
    ../Hardware/TIMER/: TIMER.c TIMER.h
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_dma.c gd32f4xx_spi.c gd32f4xx_misc.c gd32f4xx_dci.c gd32f4xx_i2c.c
    ../../../../DMA_DCI/Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_timer.c
  group Doc
    ../Doc/: readme.txt
